## Package/buildroot/Config.in
```kconfig
config BR2_PACKAGE_LIBIOPCCMD_CLIENT
	bool "libiopccmd_client"
	select BR2_PACKAGE_LIBIOPCCOMMON
	help
	  The client commands library of IOPC.
```
